# Keil uVision project Bitmap.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Bitmap
  c flags: Optim=1
  c include: ..\..\LCD_Driver;.\UserCode;..\..\STM32_Lib\inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./UserCode/: STM32F10X_System.h Bitmap.c Bitmap.h main.c STM32F10X_System.c
  group System
    ./UserCode/: stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group STM32_Lib
    ../../STM32_Lib/: cortexm3_macro.s STM32F10X.lib stm32f10x_vector.s
  group LCD_Driver
    ../../LCD_Driver/: LCD_Config.h LCD_Dis.c LCD_Dis.h
